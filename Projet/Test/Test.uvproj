# Keil uVision project Test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Test
  c flags: Optim=1
  memory RVCT9: RAM 0x20000000 size 0x1000
